require pianobar.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=cfeb8ae0065c00f1bf4f5a963872e934"

PR = "${INC_PR}.0"

SRCREV = "78c898ea422fc677eed0bd3a37c4a893a8a2b85d"

S = "${WORKDIR}/git"
