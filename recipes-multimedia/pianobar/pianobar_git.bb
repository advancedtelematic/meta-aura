require pianobar.inc

PR = "${INC_PR}.0"
LIC_FILES_CHKSUM = "file://COPYING;md5=cfeb8ae0065c00f1bf4f5a963872e934"

SRCREV = "${AUTOREV}"

S = "${WORKDIR}/git"
